# IAR project 05-dc2369a.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa039,Pa050,Pe767,Go005,Pa082,Pa089,Pe167,Pe550,Pe188,Pe177
  ICCARM.IExtraOptions: --no_path_in_file_macros; --enum_is_int
  ICCARM.PreInclude: ..\all_projects.iarinc
  ICCARM.CCIncludePath2: ..\..\..\src\app\05-dc2369a\; ..\..\..\src\app\common\; ..\..\..\src\inc\; ..\..\..\src\modules\clilib\; ..\..\..\src\modules\ip_applib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: C:\Python27\python.exe "..\..\..\tools\dustElfToBin\dustElfToBin.py" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: ocfdk_05_dc2369a.out
  ILINK.IlinkConfigDefines: use_loader=1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Linear\DustNetworks\Eterna.icf
  ILINK.IlinkProgramEntryLabel: __reset_handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
